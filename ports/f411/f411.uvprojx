# Keil uVision project f411.uvprojx, settings and files
target F411_C (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x08000000-0x0807FFFF) CLOCK(96000000) FPU2 CPUTYPE("Cortex-M4")
  output: f411 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c misc: --no_exceptions --no_rtti
  c include: ../../algorithm;.;../../device/mpu6050;../../protocol/frame;../../protocol/crc;../../Drivers/CMSIS/Include;../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../Drivers/STM32F4xx_HAL_Driver/Inc
  asm include: ../../algorithm;
  memory RVCT4: RAM 0x20000000 size 0x20000
  memory RVCT9: ROM 0x08000000 size 0x80000
  scatter file: .\f411.sct
  group F411 shared C backend
    ./: main.c imu_c.c
    ../../device/mpu6050/: mpu6050.c
    ../../protocol/frame/: frame_codec.c
    ../../protocol/crc/: crc16_modbus.c
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f411xe.s
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma.c
    ../../algorithm/: week5_timing.c
target F411_CPP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: as above
  output: f411 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c misc: --no_exceptions --no_rtti
  c include: as above
  asm include: ../../algorithm;
  memory RVCT4: RAM 0x20000000 size 0x20000
  memory RVCT9: ROM 0x08000000 size 0x80000
  scatter file: .\f411.sct
  group added to the first target's files
    ./: imu_cpp.cpp
  group left out of the first target's files
    ./: imu_c.c
software components: CMSIS:CORE 4.3.0
